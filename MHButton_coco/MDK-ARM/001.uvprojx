# Keil uVision project 001.uvprojx, settings and files
target 001 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: 001 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../COCOLIB/ESP8266;../COCOInclude;../COCOTASK;../COCOLIB/W5500_TCPC;../FreeModbus/modbus/ascii;../FreeModbus/modbus/functions;../FreeModbus/modbus/include;../FreeModbus/modbus/tcp;../FreeModbus/modbus/rtu;../FreeModbus/port_fm;../COCOLIB/W25Q64;../COCOLIB/BL8025
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group COCOInclude
    ../COCOInclude/: myinclude.h globalVariable.c globalVariable.h
  group Application/MDK-ARM
    ./: startup_stm32f030xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c spi.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group COCOTASK
    ../COCOTASK/: COCO_StartOsTaskSub.c COCO_StartOsTaskSub.h KeyTask.c KeyTask.h DiabcTask.c DiabcTask.h KeyTimerTask.c KeyTimerTask.h NetBridgeModbusTask.c NetBridgeModbusTask.h WifiTask.c WifiTask.h W5500Task.c W5500Task.h WifiSendTask.c WifiSendTask.h W5500SendTask.c W5500SendTask.h powerDownDoTask.c powerDownDoTask.h eMBPollTask.c eMBPollTask.h monitoringTask.c monitoringTask.h
  group COCOLIB/ESP8266
    ../COCOLIB/ESP8266/: atk_mw8266d.c atk_mw8266d.h atk_mw8266d_struct.h atk_mw8266d_uart.c atk_mw8266d_uart.h
  group COCOLIB/W5500_TCPC
    ../COCOLIB/W5500_TCPC/: w5500_conf.c w5500_conf.h w5500.c w5500.h socket.c socket.h utility.c utility.h types.h dhcp.c dhcp.h tcp_dowithSub.c tcp_dowithSub.h
  group COCOLIB/25Q64
    ../COCOLIB/W25Q64/: w25q64.c w25q64.h
  group COCOLIB/BL8025
    ../COCOLIB/BL8025/: BL8025.c BL8025.h
  group FreeModbus/port_fm
    ../FreeModbus/port_fm/: port_fm.c porttcp.c portserial.c porttimer.c portevent.c
  group FreeModbus/modbus
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/include/: mbconfig.h
    ../FreeModbus/modbus/ascii/: mbascii.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/tcp/: mbtcp.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
